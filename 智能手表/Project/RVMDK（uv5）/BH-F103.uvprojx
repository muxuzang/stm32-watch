# Keil uVision project BH-F103.uvprojx, settings and files
target HC05 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HC05 +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User;..\..\SYSTEM;..\..\User\usart;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\User\meau;..\..\User\LCD;..\..\User\SPI;..\..\User\rtc;..\..\User\SysTick;..\..\User\ADXL345;..\..\User\MAX30102;..\..\User\MAX30102\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/Key/: bsp_key.c
    ../../User/usart/: bsp_usart.c bsp_usart_blt.c ESP8266.c
    ../../User/dwt_delay/: core_delay.c
    ../../User/meau/: meau.c
    ../../User/LCD/: GUI.c lcd.c test.c
    ../../User/SPI/: SPI.c
    ../../User/ADXL345/: adxl345.c
    ../../User/MAX30102/: algorithm.c max30102.c
    ../../User/rtc/: bsp_calendar.c bsp_date.c bsp_rtc.c
  group DOC
    ../../Doc/: readme.txt
  group SYSTEM
    ../../SYSTEM/delay/: delay.c
    ../../SYSTEM/sys/: sys.c
    ../../User/MAX30102/IIC/: iic.c
